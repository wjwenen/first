# Keil uVision project ADC_test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC_test
  c flags: Optim=1
  c include: ..\Libraries\inc;..\App;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/: main.c stm32f10x_it.c
  group StdPeriph
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../User/: delay.c led.c adc.c
  group CMSIS
    ../Libraries/CM3/CoreSupport/: core_cm3.c system_stm32f10x.c
    ../Libraries/CM3/StartUp/: startup_stm32f10x_md.s
